# Keil uVision project t2.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C32 Intel
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: t2
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: t2.asm
